# Keil uVision project UART_TxRx_Function.uvproj, settings and files
target UART_TxRx_Function (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M0518SD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: UART_TxRxFunction
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\M0518_FW;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\M0518\Include;..\..\M0518_FW;..\..\Library\StdDriver\inc;..\..\Library\StdDriver\src;..\..\M0518_FW;..\KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M0518.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/M0518/Source/ARM/: startup_M0518.s
    ../../Library/Device/Nuvoton/M0518/Source/: system_M0518.c
  group User
    ../: main.c
    ./: circleq.c circleq.h my9168.c my9168.h
  group Library
    ../../Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c sys.c uart.c
